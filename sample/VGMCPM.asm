;
; YM2203 VGM PLAY FOR CP/M-80
;
	CPU	Z80

TARGET:	equ	"Z80"

BDOS	EQU	0005H
DMA	EQU	0008H
FCB	EQU	005CH

OPM_ADDR	EQU	040H
OPM_DATA	EQU	041H
;

;
	ORG	100H
;
MAIN:
	LD	DE,FCB		
	LD	C,0FH		;ファイルOPEN
	CALL	BDOS
	OR	A			;成功?
	JP	NZ,OPEN_ERROR
;
	CALL	MAIN1		
	RET
;
OPEN_ERROR:
	LD	DE,ERMSG1	;ERROR MSG
	LD	C,09H		;string output function
	CALL	BDOS
	RET		
;
READ_ERROR:
	LD	DE,ERMSG2	;ERROR MSG
	LD	C,09H		;string output function
	CALL	BDOS
	RET		
;
GETDATA:
	PUSH DE
	LD	A,(HL)	; GET COMMAND
	PUSH AF
	INC	HL
;
; バッファEND判定
;
	LD  DE,DMAEND
	EX  DE,HL
	SBC HL,DE
	JP  NZ,GETDATA_END
;
; シーケンシャル読み出し
;
	LD	DE,FCB
	LD	C,014h
	CALL BDOS
	OR  A
	JP  NZ,READ_ERROR
;
	LD  DE,NEWDMA
;
GETDATA_END:
	EX DE,HL
	POP AF
	POP DE
	RET

MAIN1:
	LD	DE,NEWDMA
	LD	C,1AH		;set DMA address function
	CALL	BDOS

	LD	DE,FCB
	LD	C,014h
	CALL BDOS
	OR  A
	JP  NZ,READ_ERROR
;
	LD HL,NEWDMA
LOOP:
	CALL GETDATA	; 1バイトデータ取得
	CP	055H
	JP	Z,PLAY
	CP	061H
	JP	Z,WAIT1
	CP	062H
	JP	Z,WAIT2
	CP	063H
	JP	Z,WAIT3
	CP	064H
	JP	Z,WAIT3
	CP	066H
	JP	Z,END_RTN
;
	CP	70H
	JP	Z,WAIT4
	JP	NZ,CHK_WAIT
NEXT:
	JP	LOOP
;
END_RTN:
	RET	; GOTO MAIN	
;
PLAY:
	CALL GETDATA
	LD 	D,A
	CALL GETDATA
	LD 	E,A
WRITEOPN:
; STATUS CHECK WAIT
	IN  A,(OPM_ADDR)
	RLCA
	JR      C,WRITEOPN
; REG OUT
	LD      A,D
	OUT     (OPM_ADDR),A
	LD      A,(IX+0)        ;DUMMY
; DATA OUT
	LD      A,E
	OUT     (OPM_DATA),A
	JP 	NEXT
;
WAIT1:
	CALL GETDATA
	LD	E,A
	CALL GETDATA
	LD	D,A
	CALL	WAIT
	JP NEXT
;
WAIT2:
	LD	DE,735	
	CALL	WAIT
	JP 	NEXT
;
WAIT3:
	LD 	DE,882
	CALL 	WAIT
	JP 	NEXT
;
CHK_WAIT:
	CP	80H
	JP	NC,NEXT
WAIT4:
	AND	0FH
	INC	A
	LD 	D,0
	LD	E,A
	CALL	WAIT
	JP 	NEXT
;  
WAIT:	
	CALL	WAIT1MS	
	DEC	DE		
	LD	A,D
	OR	E
	JR	NZ,WAIT
	RET		
; 
WAIT1MS:	
	LD	BC,1		 
WAIT1MSLOOP:
	DEC	BC
;	NOP		;DUMMY (clock 4)
	LD	A,C
	OR	B
	JR	NZ,WAIT1MSLOOP
	RET
;
;
;
;
ERMSG1:	DB	'Cannot open that file.$'
ERMSG2:	DB	'file read error.$'
NEWDMA  DS  128
DMAEND	EQU $
END
